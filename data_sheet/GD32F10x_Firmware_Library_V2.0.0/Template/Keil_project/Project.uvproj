# Keil uVision project Project.uvproj, settings and files
target GD32F10X_CL (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: GD32F107VC GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_CL
  c include: ..\..\Firmware\GD32F10x_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\Firmware\CMSIS;..\..\Utilities;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../: main.c systick.c gd32f10x_it.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_bkp.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_exmc.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_i2c.c gd32f10x_pmu.c gd32f10x_rtc.c gd32f10x_spi.c gd32f10x_usart.c gd32f10x_wwdgt.c gd32f10x_rcu.c gd32f10x_exti.c gd32f10x_adc.c gd32f10x_can.c gd32f10x_dbg.c gd32f10x_enet.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_dma.c gd32f10x_timer.c gd32f10x_sdio.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s startup_gd32f10x_hd.s startup_gd32f10x_md.s startup_gd32f10x_xd.s
  group Utilities
    ../../Utilities/: gd32f10x_eval.c
  group Doc
    ../: readme.txt
target GD32F10X_MD (ARM-ADS)
  device: GD32F103VB GigaDevice
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: ..\..\Firmware\GD32F10x_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\Utilities;..\..\Firmware\CMSIS;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target GD32F10X_HD (ARM-ADS)
  device: GD32F103VC GigaDevice
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target GD32F10X_XD (ARM-ADS)
  device: GD32F103VK GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x082FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_XD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x18000
